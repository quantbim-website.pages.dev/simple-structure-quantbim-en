Properties of the parts of a building model (IFC4X3_ADD2)

# File
Description: ViewDefinition [CoordinationView], RevitIdentifiers [ContentGUID: 8e6cc76b-c197-44d1-83c5-72b8ec8dc489, VersionGUID: 28d12f2a-c6f7-4d25-8328-fec1f8a01c47, NumberOfSaves: 52], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Internal]
File name: Simple_structure.ifc
Time: 2026-06-14T23:28:29+01:00
Written by: ODA SDAI 24.12
Made in: Autodesk Revit 25.4.0.32 (ENU) - IFC 25.4.0.27

# IfcProject, Simple concrete
LongName: Simple concrete; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_SiteCommon - Reference: Project Information
Pset_SpaceCommon - Reference: Project Information; IsExternal: no
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Simple concrete; Project Number: Simple concrete; Project Status: Project Status
Identity Data - Author: FJ; Building Name: Simple concrete; Organization Name: QuantBIM

# IfcBuilding, Simple concrete
LongName: Simple concrete
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 2
Pset_BuildingElementProxyCommon - Reference: Project Information; IsExternal: no; sets with these values: 2
Pset_BuildingStoreyCommon - Reference: Project Information; sets with these values: 2
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Simple concrete; Project Number: Simple concrete; Project Status: Project Status
Identity Data - Author: FJ; Building Name: Simple concrete; Organization Name: QuantBIM

# IfcBuildingStorey: Level:8mm Head (2)
In: Simple concrete
Pset_BuildingStoreyCommon - Reference: 8mm Head
Pset_SpaceCommon - IsExternal: no; Reference: 8mm Head
Other - Category: Levels; Family: Level; Family and Type: Level: 8mm Head; Type: 8mm Head; Type Id: 305
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Structural: no
Other(Type) - Category: Levels; Family Name: Level
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: 8mm Head
Name | LongName = Name | Elevation (mm) = Constraints, Elevation (mm)
Level 1 | Level 1 | 0
Level 2 | Level 2 | 4000

# IfcBeam: M_Concrete-Rectangular Beam:400 x 800mm, M_Concrete-Rectangular Beam:400 x 800mm:347042
In: Level 2
Type - PredefinedType: BEAM; Material: Concrete, Cast-in-Place gray
Type - Other - Category: Structural Framing; Family Name: M_Concrete-Rectangular Beam
Type - Dimensions - b: 400 mm; h: 800 mm
Type - Identity Data - OmniClass Number: 23.25.30.11.14.14; OmniClass Title: Beams; Type Name: 400 x 800mm
Type - Structural - Section Shape: 0
Type - Pset_BeamCommon - LoadBearing: yes
Pset_BeamCommon - IsExternal: no; Reference: 400 x 800mm; Span: 8000 mm; Slope: 0 deg; Roll: 0 deg
Pset_EnvironmentalImpactIndicators - Reference: 400 x 800mm; sets with these values: 2
Other - Family: M_Concrete-Rectangular Beam; Family and Type: M_Concrete-Rectangular Beam: 400 x 800mm; Type: 400 x 800mm; Type Id: 347017
Constraints - Cross-Section Rotation: 0 deg; End Level Offset: 0 mm; Orientation: Normal; Reference Level: Level 2; Reference Level Elevation: 4000 mm; Start Level Offset: 0 mm; Work Plane: Level : Level 2
Dimensions - Elevation at Bottom: 3200 mm; Elevation at Top: 4000 mm; Length: 8000 mm; Volume: 2.368 m3
Identity Data - Has Association: yes
Materials and Finishes - Structural Material: Concrete, Cast-in-Place gray
Phasing - Phase Created: New Construction
Structural - Rebar Cover - Other Faces: Rebar Cover 1 <25 mm>; Rebar Cover - Top Face: Rebar Cover 1 <25 mm>; Cut Length: 7400 mm; End Attachment Type: End Elevation; Estimated Reinforcement Volume: 0.0187791 m3; Rebar Cover - Bottom Face: Rebar Cover 2 <40 mm>; Start Attachment Type: End Elevation; Structural Usage: Other
Geometric Position - Join Status: Both joins enabled; y Justification: Origin; y Offset Value: 0 mm; yz Justification: Uniform; z Justification: Top; z Offset Value: 0 mm

# IfcBuildingElementProxy: Foundation Slab:Bedding layer (2)
In: Level 1
Material: Site - Hardcore 200 mm
Other - Category: Structural Foundations; Family: Foundation Slab; Family and Type: Foundation Slab: Bedding layer; Type: Bedding layer; Type Id: 385039
Constraints - Level: Level 1; Related to Mass: no; Height Offset From Level: -510 mm
Dimensions - Area: 2.16 m2; Core Thickness: 200 mm; Elevation at Bottom: -710 mm; Elevation at Bottom Core: -710 mm; Elevation at Bottom Survey: -710 mm; Elevation at Top: -510 mm; Elevation at Top Core: -510 mm; Elevation at Top Survey: -510 mm; Length: 1200 mm; Perimeter: 6000 mm; Thickness: 200 mm; Volume: 0.432 m3; Width: 1800 mm
Identity Data - Has Association: no
Phasing - Phase Created: New Construction
Structural - Rebar Cover - Bottom Face: Rebar Cover 1 <25 mm>; Rebar Cover - Other Faces: Rebar Cover 1 <25 mm>; Structural: yes
Other(Type) - Category: Structural Foundations; Family Name: Foundation Slab
Construction(Type) - Default Thickness: 200 mm
Dimensions(Type) - Foundation Thickness: 200 mm
Graphics(Type) - Coarse Scale Fill Color: 0
Identity Data(Type) - Type Name: Bedding layer
Materials and Finishes(Type) - Structural Material: Site - Hardcore
Analytical Properties(Type) - Absorptance: 0.7; Roughness: 3
Name (Foundation Slab:Bedding layer:...)
385023
385093

# IfcBuildingElementProxy: Foundation Slab:Blinding concrete (2)
In: Level 1
Material: Concrete, Cast In Situ 60 mm
Other - Category: Structural Foundations; Family: Foundation Slab; Family and Type: Foundation Slab: Blinding concrete; Type: Blinding concrete; Type Id: 384620
Constraints - Level: Level 1; Height Offset From Level: -450 mm; Related to Mass: no
Dimensions - Area: 2.16 m2; Core Thickness: 60 mm; Elevation at Bottom: -510 mm; Elevation at Bottom Core: -510 mm; Elevation at Bottom Survey: -510 mm; Elevation at Top: -450 mm; Elevation at Top Core: -450 mm; Elevation at Top Survey: -450 mm; Length: 1200 mm; Perimeter: 6000 mm; Thickness: 60 mm; Volume: 0.1296 m3; Width: 1800 mm
Identity Data - Has Association: no
Phasing - Phase Created: New Construction
Structural - Rebar Cover - Other Faces: Rebar Cover 1 <25 mm>; Structural: yes
Other(Type) - Category: Structural Foundations; Family Name: Foundation Slab
Construction(Type) - Default Thickness: 60 mm
Dimensions(Type) - Foundation Thickness: 60 mm
Graphics(Type) - Coarse Scale Fill Color: 0
Identity Data(Type) - Type Name: Blinding concrete
Materials and Finishes(Type) - Structural Material: Concrete, Cast In Situ
Analytical Properties(Type) - Absorptance: 0.7; Heat Transfer Coefficient (U): 17.4333 kg/K/s3; Roughness: 3; Thermal Mass: 90666 kg/K/s2; Thermal Resistance (R): 0.0573614 s3*K/kg
Name (Foundation Slab:Blinding concrete:...)
384617
384994

# IfcColumn: M_Concrete-Rectangular-Column:400 x 600mm (2)
In: Level 1
Type - PredefinedType: COLUMN; Material: Concrete, Cast-in-Place gray
Type - Other - Category: Structural Columns; Family Name: M_Concrete-Rectangular-Column
Type - Dimensions - b: 400 mm; h: 600 mm
Type - Identity Data - OmniClass Number: 23.25.30.11.14.11; OmniClass Title: Columns; Type Name: 400 x 600mm
Type - Structural - Section Shape: 0
Type - Pset_ColumnCommon - LoadBearing: yes
Pset_ColumnCommon - IsExternal: no; Reference: 400 x 600mm
Pset_EnvironmentalImpactIndicators - Reference: 400 x 600mm; sets with these values: 2
Other - Family: M_Concrete-Rectangular-Column; Family and Type: M_Concrete-Rectangular-Column: 400 x 600mm; Type: 400 x 600mm; Type Id: 346010
Constraints - Base Level: Level 1; Base Offset: 0 mm; Column Style: Vertical; Level: Level 1; Moves With Grids: yes; Room Bounding: yes; Top Level: Level 2; Top Offset: 0 mm
Dimensions - Length: 4000 mm; Volume: 0.96 m3
Identity Data - Has Association: yes
Materials and Finishes - Structural Material: Concrete, Cast-in-Place gray
Phasing - Phase Created: New Construction
Structural - Rebar Cover - Bottom Face: Rebar Cover 1 <25 mm>; Rebar Cover - Other Faces: Rebar Cover 1 <25 mm>; Rebar Cover - Top Face: Rebar Cover 1 <25 mm>
Name (M_Concrete-Rectangular-Column:400 x 600mm:...) | Column Location Mark | Estimated Reinforcement Volume (m3)
346096 | A-1 | 0.00986586
377905 | A-2 | 0.00985907 | Pset_ColumnCommon - Slope: 0 deg

# IfcFooting: M_Footing-Rectangular:1800 x 1200 x 450mm (2)
In: Level 1
Type - Material: Concrete, Cast-in-Place gray
Type - Other - Category: Structural Foundations; Family Name: M_Footing-Rectangular
Type - Dimensions - Foundation Thickness: 450 mm; Length: 1800 mm; Width: 1200 mm
Type - Identity Data - OmniClass Number: 23.25.05.17; OmniClass Title: Shallow Foundations; Type Name: 1800 x 1200 x 450mm
Pset_EnvironmentalImpactIndicators - Reference: 1800 x 1200 x 450mm; sets with these values: 4
Other - Family: M_Footing-Rectangular; Family and Type: M_Footing-Rectangular: 1800 x 1200 x 450mm; Type: 1800 x 1200 x 450mm; Type Id: 347506
Constraints - Level: Level 1; Moves With Grids: yes; Height Offset From Level: 0 mm; Host: Level : Level 1
Dimensions - Area: 2.16 m2; Elevation at Bottom: -450 mm; Elevation at Bottom Survey: -450 mm; Elevation at Top: 0 mm; Elevation at Top Survey: 0 mm; Volume: 0.972 m3
Identity Data - Has Association: no
Materials and Finishes - Structural Material: Concrete, Cast-in-Place gray
Phasing - Phase Created: New Construction
Structural - Rebar Cover - Other Faces: Rebar Cover 2 <40 mm>
Name (M_Footing-Rectangular:1800 x 1200 x 450mm:...) | Rebar Cover - Top Face | Estimated Reinforcement Volume (m3)
347531 | Rebar Cover 1 <25 mm> | 0.00334542
377907 | Rebar Cover 2 <40 mm> | 0.00337256

# IfcReinforcingBar: Rebar Bar:12mm (16)
In: Level 1
Type - Other - Category: Structural Rebar; Family Name: Rebar Bar; kg_m': 1.58
Type - Construction - Deformation: Deformed
Type - Dimensions - Bar Diameter: 12 mm; Maximum Bend Radius: 18000 mm; Model Bar Diameter: 12 mm; Standard Bend Diameter: 95 mm; Standard Hook Bend Diameter: 95 mm; Stirrup/Tie Bend Diameter: 65 mm
Type - Identity Data - Type Name: 12mm
Pset_ElementComponentCommon - Reference: 12mm; sets with these values: 2
Rebar Schedule - Type: 12mm; kg_m': 1.58
Other - Family: Rebar Bar; Family and Type: Rebar Bar: 12mm; Type: 12mm; Type Id: 383492
Construction - Geometry: Shape Driven; Hook Rotation At End: 0 deg; Hook Rotation At Start: 0 deg; Modified Rebar Set: no; Override Hook Lengths: no; Rebar Constraint Status: Enabled; Staggered Set: no; Bend Diameter: 95 mm; Style: Standard
Dimensions - F: 0 mm; J: 0 mm; K: 0 mm; O: 0 mm; R: 0 mm; A: 0 mm; E: 0 mm; G: 0 mm; H: 0 mm
Phasing - Phase Created: New Construction
Rebar Set - Distribution Type: Uniform
Name (Rebar Bar:12mm :...) | Rebar Schedule, Rebar Number = Maximum Rebar Number = Minimum Rebar Number = Construction, Rebar Number | Dimensions | Rebar Schedule, Quantity = Rebar Set, Quantity = Quantity By Rebar Set | Rebar Schedule, Bar Length (mm) = Dimensions, Bar Length (mm) = Maximum Bar Length (mm) = Minimum Bar Length (mm) | Rebar Schedule, Total Bar Length (mm) = Dimensions, Total Bar Length (mm) | Schedule Mark | Shape | B (mm) | C (mm) | D (mm) | Host Category | Layout Rule | Estimated Reinforcement Volume (m3) = Reinforcement Volume (m3)
 Shape M_17:364924 | 17 | A=0 mm B=338 mm C=1680 mm D=338 mm | 6 | 2286.08 | 13740 | 2 | M_17 | 338 | 1680 | 338 | Structural Foundation | Number with Spacing | 0.00155396 | Rebar Set - Spacing: 200 mm
 Shape M_17A:366172 | 24 | A=0 mm B=1333 mm C=578 mm D=0 mm | 3 | 1875.96 | 5640 | 1 | M_17A | 1333.11 | 577.819 | 0 | Structural Column | Fixed Number | 0.000637869
 Shape M_17A:366620 | 24 | A=0 mm B=1333 mm C=578 mm D=0 mm | 3 | 1875.96 | 5640 | 1 | M_17A | 1333.11 | 577.819 | 0 | Structural Column | Fixed Number | 0.000637869
 Shape M_17:377914 | 3 | A=0 mm B=338 mm C=1720 mm D=338 mm | 6 | 2326.08 | 13980 | 2 | M_17 | 338 | 1720 | 338 | Structural Foundation | Number with Spacing | 0.0015811 | Rebar Set - Spacing: 200 mm
 Shape M_17:377916 | 4 | A=0 mm B=350 mm C=1120 mm D=350 mm | 9 | 1750.08 | 15840 | 2 | M_17 | 350 | 1120 | 350 | Structural Foundation | Number with Spacing | 0.00179146 | Rebar Set - Spacing: 200 mm
 Shape M_17A:382628 | 23 | A=0 mm B=411 mm C=1357 mm D=0 mm | 1 | 1733.49 | 1740 | 1 | M_17A | 411.347 | 1357.11 | 0 | Structural Column | Single | 0.000196789
 Shape M_17A:383083 | 23 | A=0 mm B=411 mm C=1357 mm D=0 mm | 1 | 1733.49 | 1740 | 1 | M_17A | 411.347 | 1357.11 | 0 | Structural Column | Single | 0.000196789
 Shape M_17A:383223 | 25 | A=0 mm B=1323 mm C=578 mm D=0 mm | 3 | 1866.21 | 5610 | 1 | M_17A | 1323.36 | 577.819 | 0 | Structural Column | Fixed Number | 0.000634476
 Shape M_17A:383224 | 25 | A=0 mm B=1323 mm C=578 mm D=0 mm | 3 | 1866.21 | 5610 | 1 | M_17A | 1323.36 | 577.819 | 0 | Structural Column | Fixed Number | 0.000634476
 Shape M_17A:383227 | 23 | A=0 mm B=411 mm C=1357 mm D=0 mm | 1 | 1733.49 | 1740 | 1 | M_17A | 411.347 | 1357.11 | 0 | Structural Column | Single | 0.000196789
 Shape M_17A:383228 | 23 | A=0 mm B=411 mm C=1357 mm D=0 mm | 1 | 1733.49 | 1740 | 1 | M_17A | 411.347 | 1357.11 | 0 | Structural Column | Single | 0.000196789
 Shape M_17:384015 | 4 | A=0 mm B=350 mm C=1120 mm D=350 mm | 9 | 1750.08 | 15840 | 2 | M_17 | 350 | 1120 | 350 | Structural Foundation | Number with Spacing | 0.00179146 | Rebar Set - Spacing: 200 mm
 Shape M_00:390222 | 29 | A=0 mm B=3950 mm C=0 mm D=0 mm | 1 | 3950 | 3950 | 1 | M_00 | 3950 | 0 | 0 | Structural Column | Single | 0.000446734
 Shape M_00:390427 | 29 | A=0 mm B=3950 mm C=0 mm D=0 mm | 1 | 3950 | 3950 | 1 | M_00 | 3950 | 0 | 0 | Structural Column | Single | 0.000446734
 Shape M_00:390564 | 29 | A=0 mm B=3950 mm C=0 mm D=0 mm | 1 | 3950 | 3950 | 1 | M_00 | 3950 | 0 | 0 | Structural Column | Single | 0.000446734
 Shape M_00:390565 | 29 | A=0 mm B=3950 mm C=0 mm D=0 mm | 1 | 3950 | 3950 | 1 | M_00 | 3950 | 0 | 0 | Structural Column | Single | 0.000446734

# IfcReinforcingBar: Rebar Bar:16mm (5)
In: Level 1
Type - Other - Category: Structural Rebar; Family Name: Rebar Bar; kg_m': 1.58
Type - Construction - Deformation: Deformed
Type - Dimensions - Bar Diameter: 16 mm; Maximum Bend Radius: 18000 mm; Model Bar Diameter: 16 mm; Standard Bend Diameter: 95 mm; Standard Hook Bend Diameter: 95 mm; Stirrup/Tie Bend Diameter: 65 mm
Type - Identity Data - Type Name: 16mm
Pset_ElementComponentCommon - Reference: 16mm; sets with these values: 2
Rebar Schedule - Type: 16mm; Quantity: 3; kg_m': 1.58
Other - Family: Rebar Bar; Family and Type: Rebar Bar: 16mm; Type: 16mm; Type Id: 383272
Construction - Geometry: Shape Driven; Hook Rotation At End: 0 deg; Hook Rotation At Start: 0 deg; Modified Rebar Set: no; Override Hook Lengths: no; Rebar Constraint Status: Enabled; Staggered Set: no; Style: Standard; Bend Diameter: 95 mm
Dimensions - F: 0 mm; J: 0 mm; K: 0 mm; O: 0 mm; R: 0 mm; A: 0 mm; E: 0 mm; G: 0 mm; H: 0 mm
Phasing - Phase Created: New Construction
Rebar Set - Distribution Type: Uniform; Layout Rule: Fixed Number; Quantity: 3; Quantity By Rebar Set: 3
Name (Rebar Bar:16mm :...) | Rebar Schedule, Rebar Number = Maximum Rebar Number = Minimum Rebar Number = Construction, Rebar Number | Dimensions | Rebar Schedule, Bar Length (mm) = Dimensions, Bar Length (mm) = Maximum Bar Length (mm) = Minimum Bar Length (mm) | Rebar Schedule, Total Bar Length (mm) = Dimensions, Total Bar Length (mm) | Shape | Schedule Mark | B (mm) | C (mm) | D (mm) | Host Category | Estimated Reinforcement Volume (m3) = Reinforcement Volume (m3)
 Shape M_17:378124 | 16 | A=0 mm B=712 mm C=8518 mm D=712 mm | 9862.26 | 29610 | M_17 | 3 | 711.95 | 8518 | 711.95 | Structural Framing | 0.00595344
 Shape M_17A:391497 | 28 | A=0 mm B=3915 mm C=450 mm D=0 mm | 4325.23 | 12990 | M_17A | 1 | 3915.05 | 450 | 0 | Structural Column | 0.00261179
 Shape M_17A:391498 | 28 | A=0 mm B=3915 mm C=450 mm D=0 mm | 4325.23 | 12990 | M_17A | 1 | 3915.05 | 450 | 0 | Structural Column | 0.00261179
 Shape M_17A:392848 | 28 | A=0 mm B=3915 mm C=450 mm D=0 mm | 4325.23 | 12990 | M_17A | 1 | 3915.05 | 450 | 0 | Structural Column | 0.00261179
 Shape M_17A:392849 | 28 | A=0 mm B=3915 mm C=450 mm D=0 mm | 4325.23 | 12990 | M_17A | 1 | 3915.05 | 450 | 0 | Structural Column | 0.00261179

# IfcReinforcingBar: Rebar Bar:20mm, Rebar Bar:20mm : Shape M_17:379490
In: Level 1
Type - Other - Category: Structural Rebar; kg_m': 2.3; Family Name: Rebar Bar
Type - Construction - Deformation: Deformed
Type - Dimensions - Bar Diameter: 20 mm; Maximum Bend Radius: 18000 mm; Model Bar Diameter: 20 mm; Standard Bend Diameter: 115 mm; Standard Hook Bend Diameter: 115 mm; Stirrup/Tie Bend Diameter: 115 mm
Type - Identity Data - Type Name: 20mm
Pset_ElementComponentCommon - Reference: 20mm; sets with these values: 2
Rebar Schedule - Rebar Number: 18; Type: 20mm; Dimensions: A=0 mm B=550 mm C=8486 mm D=550 mm; Quantity: 3; Bar Length: 9488.06 mm; Total Bar Length: 28470 mm; kg_m': 2.3
Other - Family: Rebar Bar; Family and Type: Rebar Bar: 20mm; Type: 20mm; Type Id: 383403
Construction - Geometry: Shape Driven; Hook Rotation At End: 0 deg; Hook Rotation At Start: 0 deg; Modified Rebar Set: no; Override Hook Lengths: no; Rebar Constraint Status: Enabled; Staggered Set: no; Shape: M_17; Style: Standard; Bend Diameter: 115 mm; Maximum Rebar Number: 18; Minimum Rebar Number: 18; Rebar Number: 18; Schedule Mark: 3
Dimensions - F: 0 mm; J: 0 mm; K: 0 mm; O: 0 mm; R: 0 mm; A: 0 mm; E: 0 mm; G: 0 mm; H: 0 mm; B: 550 mm; Bar Length: 9488.06 mm; C: 8486 mm; D: 550 mm; Maximum Bar Length: 9488.06 mm; Minimum Bar Length: 9488.06 mm; Total Bar Length: 28470 mm
Identity Data - Host Category: Structural Framing
Phasing - Phase Created: New Construction
Rebar Set - Distribution Type: Uniform; Layout Rule: Fixed Number; Quantity: 3; Quantity By Rebar Set: 3
Structural - Estimated Reinforcement Volume: 0.00894411 m3; Reinforcement Volume: 0.00894411 m3

# IfcReinforcingBar: Rebar Bar:8mm (9)
In: Level 1
Type - Other - kg_m': 0.4; Category: Structural Rebar; Family Name: Rebar Bar
Type - Construction - Deformation: Deformed
Type - Dimensions - Bar Diameter: 8 mm; Maximum Bend Radius: 18000 mm; Model Bar Diameter: 8 mm; Standard Bend Diameter: 60 mm; Standard Hook Bend Diameter: 60 mm; Stirrup/Tie Bend Diameter: 35 mm
Type - Identity Data - Type Name: 8mm
Pset_ElementComponentCommon - Reference: 8mm; sets with these values: 2
Rebar Schedule - Type: 8mm; kg_m': 0.4
Other - Family: Rebar Bar; Family and Type: Rebar Bar: 8mm; Type: 8mm; Type Id: 383357
Construction - Bend Diameter: 35 mm; Geometry: Shape Driven; Hook At End: Stirrup/Tie Seismic - 135 deg.; Hook At Start: Stirrup/Tie Seismic - 135 deg.; Hook Rotation At End: 0 deg; Hook Rotation At Start: 0 deg; Modified Rebar Set: no; Override Hook Lengths: no; Rebar Constraint Status: Enabled; Shape: M_T1; Staggered Set: no; Stirrup/Tie Attachment: Interior Face of Cover Reference; Style: Stirrup / Tie
Dimensions - A: 110 mm; F: 0 mm; G: 110 mm; H: 55.663 mm; J: 0 mm; K: 0 mm; O: 0 mm; R: 0 mm; Standard Bend Diameter: 35 mm
Phasing - Phase Created: New Construction
Rebar Set - Distribution Type: Uniform
Name (Rebar Bar:8mm : Shape M_T1:...) | Rebar Schedule, Rebar Number = Maximum Rebar Number = Minimum Rebar Number = Construction, Rebar Number | Dimensions | Rebar Schedule, Quantity = Rebar Set, Quantity = Quantity By Rebar Set | Rebar Schedule, Bar Length (mm) = Dimensions, Bar Length (mm) = Maximum Bar Length (mm) = Minimum Bar Length (mm) | Rebar Schedule, Total Bar Length (mm) = Dimensions, Total Bar Length (mm) | Schedule Mark | B (mm) = D (mm) | C (mm) = E (mm) | Host Category | Layout Rule | Spacing (mm) | Estimated Reinforcement Volume (m3) = Reinforcement Volume (m3)
361679 | 1 | A=110 mm B=350 mm C=550 mm D=350 mm | 8 | 1968.32 | 15760 | 1 | 350 | 550 | Structural Column | Number with Spacing | 150 | 0.000792184
377475 | 1 | A=110 mm B=350 mm C=550 mm D=350 mm | 6 | 1968.32 | 11820 | 1 | 350 | 550 | Structural Column | Maximum Spacing | 300 | 0.000594138
377491 | 1 | A=110 mm B=350 mm C=550 mm D=350 mm | 7 | 1968.32 | 13790 | 1 | 350 | 550 | Structural Column | Maximum Spacing | 150 | 0.000693161
377909 | 1 | A=110 mm B=350 mm C=550 mm D=350 mm | 8 | 1968.32 | 15760 | 1 | 350 | 550 | Structural Column | Number with Spacing | 150 | 0.000792184
377920 | 1 | A=110 mm B=350 mm C=550 mm D=350 mm | 6 | 1968.32 | 11820 | 1 | 350 | 550 | Structural Column | Maximum Spacing | 300 | 0.000594138
377921 | 1 | A=110 mm B=350 mm C=550 mm D=350 mm | 7 | 1968.32 | 13790 | 1 | 350 | 550 | Structural Column | Maximum Spacing | 150 | 0.000693161
379984 | 19 | A=110 mm B=735 mm C=350 mm D=735 mm | 9 | 2338.32 | 21060 | 3 | 735 | 350 | Structural Framing | Maximum Spacing | 200 | 0.00105859
380941 | 19 | A=110 mm B=735 mm C=350 mm D=735 mm | 15 | 2338.32 | 35100 | 3 | 735 | 350 | Structural Framing | Maximum Spacing | 300 | 0.00176432
380959 | 19 | A=110 mm B=735 mm C=350 mm D=735 mm | 9 | 2338.32 | 21060 | 3 | 735 | 350 | Structural Framing | Maximum Spacing | 200 | 0.00105859

# Material: Concrete, Cast-in-Place gray
Identity - Category: Concrete; Class: Concrete
Structural - Name: Concrete; Description: Default Concrete f'c=3.5 ksi; Keywords: structural:concrete; Type: Concrete; SubClass: Standard; Source: Autodesk; Behavior: Isotropic; TensileStrength: 2413294 Pa; ConcreteCompression: 24132938 Pa; ShearStrengthModification: 1; ThermallyTreated: no
Thermal - Name: Concrete(1); Description: Concrete, stone aggregate; Keywords: thermal:solid; Type: Solid; SubClass: Concrete; Source: Autodesk; Density: 2300 kg/m3; Emissivity: 0.95; Behavior: Isotropic; TransmitsLight: no; Permeability: 0 s/m; Reflectivity: 0; ElectricalResistivity: 2000000 kg*m3/s3/A2
Pset_MaterialCommon - Porosity: 0.001; MassDensity: 2407.31 kg/m3
Pset_MaterialMechanical - YoungModulus: 23250000000 kg/s2/m; ShearModulus: 9964000000 kg/s2/m; PoissonRatio: 0.167; ThermalExpansionCoefficient: 0.00001 1/K
Pset_MaterialSteel - YieldStress: 2413294 Pa
Pset_MaterialThermal - SpecificHeatCapacity: 657 m2/K/s2; ThermalConductivity: 1.046
Other - Category: Materials
Identity Data - Cost: 0; Description: Cast-in-place concrete
Materials and Finishes - Color: 12632256; Glow: no; Material Type: Concrete; Name: Concrete, Cast-in-Place gray; Shininess: 128; Smoothness: 50; Transparency: 0

# Material: Concrete, Cast In Situ
Identity - Category: Concrete; Class: Concrete
Structural - ShearStrengthModification: 1; Name: Concrete 10 MPa; Description: Concrete f'c=10 MPa; Keywords: structural:concrete; Type: Concrete; SubClass: Standard; Source: Autodesk; Behavior: Isotropic; TensileStrength: 1000000 Pa; ConcreteCompression: 10000000 Pa; ThermallyTreated: no
Thermal - Density: 2300 kg/m3; Emissivity: 0.95; Permeability: 0 s/m; Reflectivity: 0; Name: Concrete; Description: Concrete, stone aggregate; Keywords: thermal:solid; Type: Solid; SubClass: Concrete; Source: Autodesk; Behavior: Isotropic; TransmitsLight: no; ElectricalResistivity: 2000000 kg*m3/s3/A2
Pset_MaterialCommon - Porosity: 0.001; MassDensity: 2406.45 kg/m3
Pset_MaterialMechanical - YoungModulus: 20500000000 kg/s2/m; ShearModulus: 9430000000 kg/s2/m; PoissonRatio: 0.2; ThermalExpansionCoefficient: 0.00001 1/K
Pset_MaterialSteel - YieldStress: 1000000 Pa
Pset_MaterialThermal - SpecificHeatCapacity: 657 m2/K/s2; ThermalConductivity: 1.046
Other - Category: Materials
Identity Data - Cost: 0; Description: physical material
Materials and Finishes - Glow: no; Material Type: Concrete; Transparency: 0; Color: 12632256; Name: Concrete, Cast In Situ; Shininess: 128; Smoothness: 50

# Material: Site - Hardcore
Identity - Category: Miscellaneous; Class: Miscellaneous
Other - Category: Materials
Identity Data - Cost: 0
Materials and Finishes - Glow: no; Transparency: 0; Color: 2763429; Name: Site - Hardcore; Shininess: 0; Smoothness: 0
